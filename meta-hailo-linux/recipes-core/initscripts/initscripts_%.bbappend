FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-initscripts-Add-argument-validation-to-sendsigs-scri.patch"
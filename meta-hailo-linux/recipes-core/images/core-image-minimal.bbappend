EXTRA_IMAGE_FEATURES += "ssh-server-openssh allow-root-login"

FILES:${PN}-rtl-nic = " \
  ${nonarch_base_libdir}/firmware/rtl_nic/*.fw \
"

PACKAGES =+ "${PN}-rtl-nic"

# Customize to include dev-pkg packagegroups in case it's required
COMPLEMENTARY_GLOB[hailo-dev] = "*-dev-pkg"

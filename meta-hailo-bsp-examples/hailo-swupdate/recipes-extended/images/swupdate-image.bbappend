IMAGE_INSTALL = "\
    base-files \
    base-passwd \
    busybox \
    coreutils \
    diffutils \
    mtd-utils \
    mtd-utils-ubifs \
    libgcc \
    libconfig \
    swupdate \
    util-linux-sfdisk \
    e2fsprogs-resize2fs \
    e2fsprogs-e2fsck \
    init-ifupdown \
    virtual/initscripts-hailo-swupdate \
    run-swupdate-script \
    u-boot-fw-utils \
"
IMAGE_FSTYPES = "ext4.gz"
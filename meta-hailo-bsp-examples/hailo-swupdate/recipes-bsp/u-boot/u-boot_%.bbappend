FILESEXTRAPATHS:prepend := "${THISDIR}/:"

SRC_URI:append = " file://cfg/hailo15_swupdate_enable.cfg"

IMAGE_INSTALL:append = " packagegroup-hailo-media-library-dev-pkg"
TOOLCHAIN_HOST_TASK:append = " nativesdk-protobuf-compiler nativesdk-grpc-compiler"

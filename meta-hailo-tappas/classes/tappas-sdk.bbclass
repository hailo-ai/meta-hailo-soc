TOOLCHAIN_TARGET_TASK:append = " hailort-server-staticdev"
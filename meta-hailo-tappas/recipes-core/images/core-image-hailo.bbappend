IMAGE_INSTALL:append = " packagegroup-hailo-tappas"

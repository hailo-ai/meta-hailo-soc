IMAGE_INSTALL:append = " packagegroup-hailo-dsp"
